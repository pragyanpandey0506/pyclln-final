.title scikit_digits_dense_io_xent
.include "/home/ma-lab/Desktop/pyclln-final/device_model/nmos_lvl1_ald1106.lib"
.options klu
VMINUS 1 0 0.0000000000000000
VPLUS  2 0 0.4500000000000000
VIN0 13 0 0
VIN1 14 0 0
VIN2 15 0 0
VIN3 16 0 0
VIN4 17 0 0
VIN5 18 0 0
VIN6 19 0 0
VIN7 20 0 0
VIN8 21 0 0
VIN9 22 0 0
VIN10 23 0 0
VIN11 24 0 0
VIN12 25 0 0
VIN13 26 0 0
VIN14 27 0 0
VIN15 28 0 0
VIN16 29 0 0
VIN17 30 0 0
VIN18 31 0 0
VIN19 32 0 0
VIN20 33 0 0
VIN21 34 0 0
VIN22 35 0 0
VIN23 36 0 0
VIN24 37 0 0
VIN25 38 0 0
VIN26 39 0 0
VIN27 40 0 0
VIN28 41 0 0
VIN29 42 0 0
VIN30 43 0 0
VIN31 44 0 0
VIN32 45 0 0
VIN33 46 0 0
VIN34 47 0 0
VIN35 48 0 0
VIN36 49 0 0
VIN37 50 0 0
VIN38 51 0 0
VIN39 52 0 0
VIN40 53 0 0
VIN41 54 0 0
VIN42 55 0 0
VIN43 56 0 0
VIN44 57 0 0
VIN45 58 0 0
VIN46 59 0 0
VIN47 60 0 0
VIN48 61 0 0
VIN49 62 0 0
VIN50 63 0 0
VIN51 64 0 0
VIN52 65 0 0
VIN53 66 0 0
VIN54 67 0 0
VIN55 68 0 0
VIN56 69 0 0
VIN57 70 0 0
VIN58 71 0 0
VIN59 72 0 0
VIN60 73 0 0
VIN61 74 0 0
VIN62 75 0 0
VIN63 76 0 0
RS1 3 77 1e+09
RS2 4 78 1e+09
RS3 5 79 1e+09
RS4 6 80 1e+09
RS5 7 81 1e+09
RS6 8 82 1e+09
RS7 9 83 1e+09
RS8 10 84 1e+09
RS9 11 85 1e+09
RS10 12 86 1e+09
VOUT0 77 0 0
VOUT1 78 0 0
VOUT2 79 0 0
VOUT3 80 0 0
VOUT4 81 0 0
VOUT5 82 0 0
VOUT6 83 0 0
VOUT7 84 0 0
VOUT8 85 0 0
VOUT9 86 0 0
VG0 g0 0 4.0000000000000000
X0 13 g0 3 b0 NMOSWRAP
VG1 g1 0 4.0000000000000000
X1 13 g1 4 b1 NMOSWRAP
VG2 g2 0 4.0000000000000000
X2 13 g2 6 b2 NMOSWRAP
VG3 g3 0 4.0000000000000000
X3 13 g3 8 b3 NMOSWRAP
VG4 g4 0 4.0000000000000000
X4 13 g4 9 b4 NMOSWRAP
VG5 g5 0 4.0000000000000000
X5 13 g5 10 b5 NMOSWRAP
VG6 g6 0 4.0000000000000000
X6 13 g6 11 b6 NMOSWRAP
VG7 g7 0 4.0000000000000000
X7 13 g7 12 b7 NMOSWRAP
VG8 g8 0 4.0000000000000000
X8 14 g8 3 b8 NMOSWRAP
VG9 g9 0 4.0000000000000000
X9 14 g9 4 b9 NMOSWRAP
VG10 g10 0 4.0000000000000000
X10 14 g10 5 b10 NMOSWRAP
VG11 g11 0 4.0000000000000000
X11 14 g11 6 b11 NMOSWRAP
VG12 g12 0 4.0000000000000000
X12 14 g12 8 b12 NMOSWRAP
VG13 g13 0 4.0000000000000000
X13 14 g13 9 b13 NMOSWRAP
VG14 g14 0 4.0000000000000000
X14 14 g14 10 b14 NMOSWRAP
VG15 g15 0 4.0000000000000000
X15 14 g15 11 b15 NMOSWRAP
VG16 g16 0 4.0000000000000000
X16 14 g16 12 b16 NMOSWRAP
VG17 g17 0 4.0000000000000000
X17 15 g17 3 b17 NMOSWRAP
VG18 g18 0 4.0000000000000000
X18 15 g18 4 b18 NMOSWRAP
VG19 g19 0 4.0000000000000000
X19 15 g19 5 b19 NMOSWRAP
VG20 g20 0 4.0000000000000000
X20 15 g20 6 b20 NMOSWRAP
VG21 g21 0 4.0000000000000000
X21 15 g21 7 b21 NMOSWRAP
VG22 g22 0 4.0000000000000000
X22 15 g22 8 b22 NMOSWRAP
VG23 g23 0 4.0000000000000000
X23 15 g23 9 b23 NMOSWRAP
VG24 g24 0 4.0000000000000000
X24 15 g24 10 b24 NMOSWRAP
VG25 g25 0 4.0000000000000000
X25 15 g25 11 b25 NMOSWRAP
VG26 g26 0 4.0000000000000000
X26 15 g26 12 b26 NMOSWRAP
VG27 g27 0 4.0000000000000000
X27 16 g27 3 b27 NMOSWRAP
VG28 g28 0 4.0000000000000000
X28 16 g28 4 b28 NMOSWRAP
VG29 g29 0 4.0000000000000000
X29 16 g29 5 b29 NMOSWRAP
VG30 g30 0 4.0000000000000000
X30 16 g30 6 b30 NMOSWRAP
VG31 g31 0 4.0000000000000000
X31 16 g31 8 b31 NMOSWRAP
VG32 g32 0 4.0000000000000000
X32 16 g32 9 b32 NMOSWRAP
VG33 g33 0 4.0000000000000000
X33 16 g33 10 b33 NMOSWRAP
VG34 g34 0 4.0000000000000000
X34 16 g34 11 b34 NMOSWRAP
VG35 g35 0 4.0000000000000000
X35 16 g35 12 b35 NMOSWRAP
VG36 g36 0 4.0000000000000000
X36 17 g36 3 b36 NMOSWRAP
VG37 g37 0 4.0000000000000000
X37 17 g37 5 b37 NMOSWRAP
VG38 g38 0 4.0000000000000000
X38 17 g38 6 b38 NMOSWRAP
VG39 g39 0 4.0000000000000000
X39 17 g39 7 b39 NMOSWRAP
VG40 g40 0 4.0000000000000000
X40 17 g40 8 b40 NMOSWRAP
VG41 g41 0 4.0000000000000000
X41 17 g41 9 b41 NMOSWRAP
VG42 g42 0 4.0000000000000000
X42 17 g42 10 b42 NMOSWRAP
VG43 g43 0 4.0000000000000000
X43 17 g43 11 b43 NMOSWRAP
VG44 g44 0 4.0000000000000000
X44 17 g44 12 b44 NMOSWRAP
VG45 g45 0 4.0000000000000000
X45 18 g45 4 b45 NMOSWRAP
VG46 g46 0 4.0000000000000000
X46 18 g46 5 b46 NMOSWRAP
VG47 g47 0 4.0000000000000000
X47 18 g47 6 b47 NMOSWRAP
VG48 g48 0 4.0000000000000000
X48 18 g48 8 b48 NMOSWRAP
VG49 g49 0 4.0000000000000000
X49 18 g49 9 b49 NMOSWRAP
VG50 g50 0 4.0000000000000000
X50 18 g50 10 b50 NMOSWRAP
VG51 g51 0 4.0000000000000000
X51 18 g51 11 b51 NMOSWRAP
VG52 g52 0 4.0000000000000000
X52 18 g52 12 b52 NMOSWRAP
VG53 g53 0 4.0000000000000000
X53 19 g53 3 b53 NMOSWRAP
VG54 g54 0 4.0000000000000000
X54 19 g54 4 b54 NMOSWRAP
VG55 g55 0 4.0000000000000000
X55 19 g55 5 b55 NMOSWRAP
VG56 g56 0 4.0000000000000000
X56 19 g56 6 b56 NMOSWRAP
VG57 g57 0 4.0000000000000000
X57 19 g57 8 b57 NMOSWRAP
VG58 g58 0 4.0000000000000000
X58 19 g58 9 b58 NMOSWRAP
VG59 g59 0 4.0000000000000000
X59 19 g59 10 b59 NMOSWRAP
VG60 g60 0 4.0000000000000000
X60 19 g60 12 b60 NMOSWRAP
VG61 g61 0 4.0000000000000000
X61 20 g61 3 b61 NMOSWRAP
VG62 g62 0 4.0000000000000000
X62 20 g62 5 b62 NMOSWRAP
VG63 g63 0 4.0000000000000000
X63 20 g63 6 b63 NMOSWRAP
VG64 g64 0 4.0000000000000000
X64 20 g64 7 b64 NMOSWRAP
VG65 g65 0 4.0000000000000000
X65 20 g65 8 b65 NMOSWRAP
VG66 g66 0 4.0000000000000000
X66 20 g66 9 b66 NMOSWRAP
VG67 g67 0 4.0000000000000000
X67 20 g67 10 b67 NMOSWRAP
VG68 g68 0 4.0000000000000000
X68 20 g68 11 b68 NMOSWRAP
VG69 g69 0 4.0000000000000000
X69 20 g69 12 b69 NMOSWRAP
VG70 g70 0 4.0000000000000000
X70 21 g70 3 b70 NMOSWRAP
VG71 g71 0 4.0000000000000000
X71 21 g71 4 b71 NMOSWRAP
VG72 g72 0 4.0000000000000000
X72 21 g72 5 b72 NMOSWRAP
VG73 g73 0 4.0000000000000000
X73 21 g73 6 b73 NMOSWRAP
VG74 g74 0 4.0000000000000000
X74 21 g74 7 b74 NMOSWRAP
VG75 g75 0 4.0000000000000000
X75 21 g75 8 b75 NMOSWRAP
VG76 g76 0 4.0000000000000000
X76 21 g76 9 b76 NMOSWRAP
VG77 g77 0 4.0000000000000000
X77 21 g77 10 b77 NMOSWRAP
VG78 g78 0 4.0000000000000000
X78 21 g78 11 b78 NMOSWRAP
VG79 g79 0 4.0000000000000000
X79 21 g79 12 b79 NMOSWRAP
VG80 g80 0 4.0000000000000000
X80 22 g80 3 b80 NMOSWRAP
VG81 g81 0 4.0000000000000000
X81 22 g81 4 b81 NMOSWRAP
VG82 g82 0 4.0000000000000000
X82 22 g82 5 b82 NMOSWRAP
VG83 g83 0 4.0000000000000000
X83 22 g83 6 b83 NMOSWRAP
VG84 g84 0 4.0000000000000000
X84 22 g84 7 b84 NMOSWRAP
VG85 g85 0 4.0000000000000000
X85 22 g85 8 b85 NMOSWRAP
VG86 g86 0 4.0000000000000000
X86 22 g86 9 b86 NMOSWRAP
VG87 g87 0 4.0000000000000000
X87 22 g87 10 b87 NMOSWRAP
VG88 g88 0 4.0000000000000000
X88 22 g88 11 b88 NMOSWRAP
VG89 g89 0 4.0000000000000000
X89 22 g89 12 b89 NMOSWRAP
VG90 g90 0 4.0000000000000000
X90 23 g90 3 b90 NMOSWRAP
VG91 g91 0 4.0000000000000000
X91 23 g91 5 b91 NMOSWRAP
VG92 g92 0 4.0000000000000000
X92 23 g92 6 b92 NMOSWRAP
VG93 g93 0 4.0000000000000000
X93 23 g93 7 b93 NMOSWRAP
VG94 g94 0 4.0000000000000000
X94 23 g94 8 b94 NMOSWRAP
VG95 g95 0 4.0000000000000000
X95 23 g95 10 b95 NMOSWRAP
VG96 g96 0 4.0000000000000000
X96 23 g96 11 b96 NMOSWRAP
VG97 g97 0 4.0000000000000000
X97 23 g97 12 b97 NMOSWRAP
VG98 g98 0 4.0000000000000000
X98 24 g98 3 b98 NMOSWRAP
VG99 g99 0 4.0000000000000000
X99 24 g99 4 b99 NMOSWRAP
VG100 g100 0 4.0000000000000000
X100 24 g100 5 b100 NMOSWRAP
VG101 g101 0 4.0000000000000000
X101 24 g101 6 b101 NMOSWRAP
VG102 g102 0 4.0000000000000000
X102 24 g102 8 b102 NMOSWRAP
VG103 g103 0 4.0000000000000000
X103 24 g103 9 b103 NMOSWRAP
VG104 g104 0 4.0000000000000000
X104 24 g104 10 b104 NMOSWRAP
VG105 g105 0 4.0000000000000000
X105 24 g105 11 b105 NMOSWRAP
VG106 g106 0 4.0000000000000000
X106 24 g106 12 b106 NMOSWRAP
VG107 g107 0 4.0000000000000000
X107 25 g107 3 b107 NMOSWRAP
VG108 g108 0 4.0000000000000000
X108 25 g108 4 b108 NMOSWRAP
VG109 g109 0 4.0000000000000000
X109 25 g109 5 b109 NMOSWRAP
VG110 g110 0 4.0000000000000000
X110 25 g110 6 b110 NMOSWRAP
VG111 g111 0 4.0000000000000000
X111 25 g111 8 b111 NMOSWRAP
VG112 g112 0 4.0000000000000000
X112 25 g112 9 b112 NMOSWRAP
VG113 g113 0 4.0000000000000000
X113 25 g113 10 b113 NMOSWRAP
VG114 g114 0 4.0000000000000000
X114 25 g114 12 b114 NMOSWRAP
VG115 g115 0 4.0000000000000000
X115 26 g115 3 b115 NMOSWRAP
VG116 g116 0 4.0000000000000000
X116 26 g116 4 b116 NMOSWRAP
VG117 g117 0 4.0000000000000000
X117 26 g117 5 b117 NMOSWRAP
VG118 g118 0 4.0000000000000000
X118 26 g118 6 b118 NMOSWRAP
VG119 g119 0 4.0000000000000000
X119 26 g119 7 b119 NMOSWRAP
VG120 g120 0 4.0000000000000000
X120 26 g120 8 b120 NMOSWRAP
VG121 g121 0 4.0000000000000000
X121 26 g121 9 b121 NMOSWRAP
VG122 g122 0 4.0000000000000000
X122 26 g122 10 b122 NMOSWRAP
VG123 g123 0 4.0000000000000000
X123 26 g123 11 b123 NMOSWRAP
VG124 g124 0 4.0000000000000000
X124 26 g124 12 b124 NMOSWRAP
VG125 g125 0 4.0000000000000000
X125 27 g125 3 b125 NMOSWRAP
VG126 g126 0 4.0000000000000000
X126 27 g126 5 b126 NMOSWRAP
VG127 g127 0 4.0000000000000000
X127 27 g127 6 b127 NMOSWRAP
VG128 g128 0 4.0000000000000000
X128 27 g128 7 b128 NMOSWRAP
VG129 g129 0 4.0000000000000000
X129 27 g129 8 b129 NMOSWRAP
VG130 g130 0 4.0000000000000000
X130 27 g130 9 b130 NMOSWRAP
VG131 g131 0 4.0000000000000000
X131 27 g131 10 b131 NMOSWRAP
VG132 g132 0 4.0000000000000000
X132 27 g132 11 b132 NMOSWRAP
VG133 g133 0 4.0000000000000000
X133 27 g133 12 b133 NMOSWRAP
VG134 g134 0 4.0000000000000000
X134 28 g134 3 b134 NMOSWRAP
VG135 g135 0 4.0000000000000000
X135 28 g135 4 b135 NMOSWRAP
VG136 g136 0 4.0000000000000000
X136 28 g136 5 b136 NMOSWRAP
VG137 g137 0 4.0000000000000000
X137 28 g137 6 b137 NMOSWRAP
VG138 g138 0 4.0000000000000000
X138 28 g138 7 b138 NMOSWRAP
VG139 g139 0 4.0000000000000000
X139 28 g139 8 b139 NMOSWRAP
VG140 g140 0 4.0000000000000000
X140 28 g140 9 b140 NMOSWRAP
VG141 g141 0 4.0000000000000000
X141 28 g141 10 b141 NMOSWRAP
VG142 g142 0 4.0000000000000000
X142 28 g142 11 b142 NMOSWRAP
VG143 g143 0 4.0000000000000000
X143 28 g143 12 b143 NMOSWRAP
VG144 g144 0 4.0000000000000000
X144 29 g144 3 b144 NMOSWRAP
VG145 g145 0 4.0000000000000000
X145 29 g145 4 b145 NMOSWRAP
VG146 g146 0 4.0000000000000000
X146 29 g146 5 b146 NMOSWRAP
VG147 g147 0 4.0000000000000000
X147 29 g147 6 b147 NMOSWRAP
VG148 g148 0 4.0000000000000000
X148 29 g148 9 b148 NMOSWRAP
VG149 g149 0 4.0000000000000000
X149 29 g149 10 b149 NMOSWRAP
VG150 g150 0 4.0000000000000000
X150 29 g150 11 b150 NMOSWRAP
VG151 g151 0 4.0000000000000000
X151 29 g151 12 b151 NMOSWRAP
VG152 g152 0 4.0000000000000000
X152 30 g152 3 b152 NMOSWRAP
VG153 g153 0 4.0000000000000000
X153 30 g153 4 b153 NMOSWRAP
VG154 g154 0 4.0000000000000000
X154 30 g154 5 b154 NMOSWRAP
VG155 g155 0 4.0000000000000000
X155 30 g155 6 b155 NMOSWRAP
VG156 g156 0 4.0000000000000000
X156 30 g156 7 b156 NMOSWRAP
VG157 g157 0 4.0000000000000000
X157 30 g157 8 b157 NMOSWRAP
VG158 g158 0 4.0000000000000000
X158 30 g158 9 b158 NMOSWRAP
VG159 g159 0 4.0000000000000000
X159 30 g159 11 b159 NMOSWRAP
VG160 g160 0 4.0000000000000000
X160 30 g160 12 b160 NMOSWRAP
VG161 g161 0 4.0000000000000000
X161 31 g161 3 b161 NMOSWRAP
VG162 g162 0 4.0000000000000000
X162 31 g162 4 b162 NMOSWRAP
VG163 g163 0 4.0000000000000000
X163 31 g163 5 b163 NMOSWRAP
VG164 g164 0 4.0000000000000000
X164 31 g164 7 b164 NMOSWRAP
VG165 g165 0 4.0000000000000000
X165 31 g165 8 b165 NMOSWRAP
VG166 g166 0 4.0000000000000000
X166 31 g166 9 b166 NMOSWRAP
VG167 g167 0 4.0000000000000000
X167 31 g167 10 b167 NMOSWRAP
VG168 g168 0 4.0000000000000000
X168 31 g168 11 b168 NMOSWRAP
VG169 g169 0 4.0000000000000000
X169 31 g169 12 b169 NMOSWRAP
VG170 g170 0 4.0000000000000000
X170 32 g170 3 b170 NMOSWRAP
VG171 g171 0 4.0000000000000000
X171 32 g171 4 b171 NMOSWRAP
VG172 g172 0 4.0000000000000000
X172 32 g172 7 b172 NMOSWRAP
VG173 g173 0 4.0000000000000000
X173 32 g173 8 b173 NMOSWRAP
VG174 g174 0 4.0000000000000000
X174 32 g174 9 b174 NMOSWRAP
VG175 g175 0 4.0000000000000000
X175 32 g175 10 b175 NMOSWRAP
VG176 g176 0 4.0000000000000000
X176 32 g176 11 b176 NMOSWRAP
VG177 g177 0 4.0000000000000000
X177 32 g177 12 b177 NMOSWRAP
VG178 g178 0 4.0000000000000000
X178 33 g178 3 b178 NMOSWRAP
VG179 g179 0 4.0000000000000000
X179 33 g179 4 b179 NMOSWRAP
VG180 g180 0 4.0000000000000000
X180 33 g180 5 b180 NMOSWRAP
VG181 g181 0 4.0000000000000000
X181 33 g181 6 b181 NMOSWRAP
VG182 g182 0 4.0000000000000000
X182 33 g182 7 b182 NMOSWRAP
VG183 g183 0 4.0000000000000000
X183 33 g183 9 b183 NMOSWRAP
VG184 g184 0 4.0000000000000000
X184 33 g184 10 b184 NMOSWRAP
VG185 g185 0 4.0000000000000000
X185 33 g185 11 b185 NMOSWRAP
VG186 g186 0 4.0000000000000000
X186 33 g186 12 b186 NMOSWRAP
VG187 g187 0 4.0000000000000000
X187 34 g187 3 b187 NMOSWRAP
VG188 g188 0 4.0000000000000000
X188 34 g188 4 b188 NMOSWRAP
VG189 g189 0 4.0000000000000000
X189 34 g189 5 b189 NMOSWRAP
VG190 g190 0 4.0000000000000000
X190 34 g190 6 b190 NMOSWRAP
VG191 g191 0 4.0000000000000000
X191 34 g191 7 b191 NMOSWRAP
VG192 g192 0 4.0000000000000000
X192 34 g192 10 b192 NMOSWRAP
VG193 g193 0 4.0000000000000000
X193 34 g193 11 b193 NMOSWRAP
VG194 g194 0 4.0000000000000000
X194 34 g194 12 b194 NMOSWRAP
VG195 g195 0 4.0000000000000000
X195 35 g195 3 b195 NMOSWRAP
VG196 g196 0 4.0000000000000000
X196 35 g196 4 b196 NMOSWRAP
VG197 g197 0 4.0000000000000000
X197 35 g197 5 b197 NMOSWRAP
VG198 g198 0 4.0000000000000000
X198 35 g198 6 b198 NMOSWRAP
VG199 g199 0 4.0000000000000000
X199 35 g199 7 b199 NMOSWRAP
VG200 g200 0 4.0000000000000000
X200 35 g200 8 b200 NMOSWRAP
VG201 g201 0 4.0000000000000000
X201 35 g201 9 b201 NMOSWRAP
VG202 g202 0 4.0000000000000000
X202 35 g202 10 b202 NMOSWRAP
VG203 g203 0 4.0000000000000000
X203 35 g203 11 b203 NMOSWRAP
VG204 g204 0 4.0000000000000000
X204 35 g204 12 b204 NMOSWRAP
VG205 g205 0 4.0000000000000000
X205 36 g205 3 b205 NMOSWRAP
VG206 g206 0 4.0000000000000000
X206 36 g206 4 b206 NMOSWRAP
VG207 g207 0 4.0000000000000000
X207 36 g207 5 b207 NMOSWRAP
VG208 g208 0 4.0000000000000000
X208 36 g208 6 b208 NMOSWRAP
VG209 g209 0 4.0000000000000000
X209 36 g209 7 b209 NMOSWRAP
VG210 g210 0 4.0000000000000000
X210 36 g210 8 b210 NMOSWRAP
VG211 g211 0 4.0000000000000000
X211 36 g211 9 b211 NMOSWRAP
VG212 g212 0 4.0000000000000000
X212 36 g212 10 b212 NMOSWRAP
VG213 g213 0 4.0000000000000000
X213 36 g213 11 b213 NMOSWRAP
VG214 g214 0 4.0000000000000000
X214 36 g214 12 b214 NMOSWRAP
VG215 g215 0 4.0000000000000000
X215 37 g215 3 b215 NMOSWRAP
VG216 g216 0 4.0000000000000000
X216 37 g216 4 b216 NMOSWRAP
VG217 g217 0 4.0000000000000000
X217 37 g217 5 b217 NMOSWRAP
VG218 g218 0 4.0000000000000000
X218 37 g218 6 b218 NMOSWRAP
VG219 g219 0 4.0000000000000000
X219 37 g219 7 b219 NMOSWRAP
VG220 g220 0 4.0000000000000000
X220 37 g220 8 b220 NMOSWRAP
VG221 g221 0 4.0000000000000000
X221 37 g221 9 b221 NMOSWRAP
VG222 g222 0 4.0000000000000000
X222 37 g222 10 b222 NMOSWRAP
VG223 g223 0 4.0000000000000000
X223 37 g223 11 b223 NMOSWRAP
VG224 g224 0 4.0000000000000000
X224 37 g224 12 b224 NMOSWRAP
VG225 g225 0 4.0000000000000000
X225 38 g225 3 b225 NMOSWRAP
VG226 g226 0 4.0000000000000000
X226 38 g226 4 b226 NMOSWRAP
VG227 g227 0 4.0000000000000000
X227 38 g227 5 b227 NMOSWRAP
VG228 g228 0 4.0000000000000000
X228 38 g228 6 b228 NMOSWRAP
VG229 g229 0 4.0000000000000000
X229 38 g229 7 b229 NMOSWRAP
VG230 g230 0 4.0000000000000000
X230 38 g230 8 b230 NMOSWRAP
VG231 g231 0 4.0000000000000000
X231 38 g231 9 b231 NMOSWRAP
VG232 g232 0 4.0000000000000000
X232 38 g232 10 b232 NMOSWRAP
VG233 g233 0 4.0000000000000000
X233 38 g233 11 b233 NMOSWRAP
VG234 g234 0 4.0000000000000000
X234 38 g234 12 b234 NMOSWRAP
VG235 g235 0 4.0000000000000000
X235 39 g235 3 b235 NMOSWRAP
VG236 g236 0 4.0000000000000000
X236 39 g236 4 b236 NMOSWRAP
VG237 g237 0 4.0000000000000000
X237 39 g237 7 b237 NMOSWRAP
VG238 g238 0 4.0000000000000000
X238 39 g238 8 b238 NMOSWRAP
VG239 g239 0 4.0000000000000000
X239 39 g239 9 b239 NMOSWRAP
VG240 g240 0 4.0000000000000000
X240 39 g240 10 b240 NMOSWRAP
VG241 g241 0 4.0000000000000000
X241 39 g241 11 b241 NMOSWRAP
VG242 g242 0 4.0000000000000000
X242 39 g242 12 b242 NMOSWRAP
VG243 g243 0 4.0000000000000000
X243 40 g243 4 b243 NMOSWRAP
VG244 g244 0 4.0000000000000000
X244 40 g244 6 b244 NMOSWRAP
VG245 g245 0 4.0000000000000000
X245 40 g245 7 b245 NMOSWRAP
VG246 g246 0 4.0000000000000000
X246 40 g246 8 b246 NMOSWRAP
VG247 g247 0 4.0000000000000000
X247 40 g247 9 b247 NMOSWRAP
VG248 g248 0 4.0000000000000000
X248 40 g248 10 b248 NMOSWRAP
VG249 g249 0 4.0000000000000000
X249 40 g249 11 b249 NMOSWRAP
VG250 g250 0 4.0000000000000000
X250 40 g250 12 b250 NMOSWRAP
VG251 g251 0 4.0000000000000000
X251 41 g251 4 b251 NMOSWRAP
VG252 g252 0 4.0000000000000000
X252 41 g252 5 b252 NMOSWRAP
VG253 g253 0 4.0000000000000000
X253 41 g253 6 b253 NMOSWRAP
VG254 g254 0 4.0000000000000000
X254 41 g254 7 b254 NMOSWRAP
VG255 g255 0 4.0000000000000000
X255 41 g255 8 b255 NMOSWRAP
VG256 g256 0 4.0000000000000000
X256 41 g256 9 b256 NMOSWRAP
VG257 g257 0 4.0000000000000000
X257 41 g257 10 b257 NMOSWRAP
VG258 g258 0 4.0000000000000000
X258 41 g258 11 b258 NMOSWRAP
VG259 g259 0 4.0000000000000000
X259 41 g259 12 b259 NMOSWRAP
VG260 g260 0 4.0000000000000000
X260 42 g260 3 b260 NMOSWRAP
VG261 g261 0 4.0000000000000000
X261 42 g261 4 b261 NMOSWRAP
VG262 g262 0 4.0000000000000000
X262 42 g262 5 b262 NMOSWRAP
VG263 g263 0 4.0000000000000000
X263 42 g263 7 b263 NMOSWRAP
VG264 g264 0 4.0000000000000000
X264 42 g264 8 b264 NMOSWRAP
VG265 g265 0 4.0000000000000000
X265 42 g265 9 b265 NMOSWRAP
VG266 g266 0 4.0000000000000000
X266 42 g266 10 b266 NMOSWRAP
VG267 g267 0 4.0000000000000000
X267 42 g267 11 b267 NMOSWRAP
VG268 g268 0 4.0000000000000000
X268 42 g268 12 b268 NMOSWRAP
VG269 g269 0 4.0000000000000000
X269 43 g269 3 b269 NMOSWRAP
VG270 g270 0 4.0000000000000000
X270 43 g270 4 b270 NMOSWRAP
VG271 g271 0 4.0000000000000000
X271 43 g271 5 b271 NMOSWRAP
VG272 g272 0 4.0000000000000000
X272 43 g272 7 b272 NMOSWRAP
VG273 g273 0 4.0000000000000000
X273 43 g273 8 b273 NMOSWRAP
VG274 g274 0 4.0000000000000000
X274 43 g274 10 b274 NMOSWRAP
VG275 g275 0 4.0000000000000000
X275 43 g275 11 b275 NMOSWRAP
VG276 g276 0 4.0000000000000000
X276 43 g276 12 b276 NMOSWRAP
VG277 g277 0 4.0000000000000000
X277 44 g277 3 b277 NMOSWRAP
VG278 g278 0 4.0000000000000000
X278 44 g278 4 b278 NMOSWRAP
VG279 g279 0 4.0000000000000000
X279 44 g279 5 b279 NMOSWRAP
VG280 g280 0 4.0000000000000000
X280 44 g280 6 b280 NMOSWRAP
VG281 g281 0 4.0000000000000000
X281 44 g281 7 b281 NMOSWRAP
VG282 g282 0 4.0000000000000000
X282 44 g282 8 b282 NMOSWRAP
VG283 g283 0 4.0000000000000000
X283 44 g283 9 b283 NMOSWRAP
VG284 g284 0 4.0000000000000000
X284 44 g284 10 b284 NMOSWRAP
VG285 g285 0 4.0000000000000000
X285 44 g285 11 b285 NMOSWRAP
VG286 g286 0 4.0000000000000000
X286 44 g286 12 b286 NMOSWRAP
VG287 g287 0 4.0000000000000000
X287 45 g287 3 b287 NMOSWRAP
VG288 g288 0 4.0000000000000000
X288 45 g288 4 b288 NMOSWRAP
VG289 g289 0 4.0000000000000000
X289 45 g289 5 b289 NMOSWRAP
VG290 g290 0 4.0000000000000000
X290 45 g290 6 b290 NMOSWRAP
VG291 g291 0 4.0000000000000000
X291 45 g291 7 b291 NMOSWRAP
VG292 g292 0 4.0000000000000000
X292 45 g292 8 b292 NMOSWRAP
VG293 g293 0 4.0000000000000000
X293 45 g293 9 b293 NMOSWRAP
VG294 g294 0 4.0000000000000000
X294 45 g294 10 b294 NMOSWRAP
VG295 g295 0 4.0000000000000000
X295 45 g295 11 b295 NMOSWRAP
VG296 g296 0 4.0000000000000000
X296 45 g296 12 b296 NMOSWRAP
VG297 g297 0 4.0000000000000000
X297 46 g297 3 b297 NMOSWRAP
VG298 g298 0 4.0000000000000000
X298 46 g298 4 b298 NMOSWRAP
VG299 g299 0 4.0000000000000000
X299 46 g299 6 b299 NMOSWRAP
VG300 g300 0 4.0000000000000000
X300 46 g300 7 b300 NMOSWRAP
VG301 g301 0 4.0000000000000000
X301 46 g301 8 b301 NMOSWRAP
VG302 g302 0 4.0000000000000000
X302 46 g302 9 b302 NMOSWRAP
VG303 g303 0 4.0000000000000000
X303 46 g303 10 b303 NMOSWRAP
VG304 g304 0 4.0000000000000000
X304 46 g304 11 b304 NMOSWRAP
VG305 g305 0 4.0000000000000000
X305 47 g305 3 b305 NMOSWRAP
VG306 g306 0 4.0000000000000000
X306 47 g306 4 b306 NMOSWRAP
VG307 g307 0 4.0000000000000000
X307 47 g307 6 b307 NMOSWRAP
VG308 g308 0 4.0000000000000000
X308 47 g308 7 b308 NMOSWRAP
VG309 g309 0 4.0000000000000000
X309 47 g309 8 b309 NMOSWRAP
VG310 g310 0 4.0000000000000000
X310 47 g310 9 b310 NMOSWRAP
VG311 g311 0 4.0000000000000000
X311 47 g311 10 b311 NMOSWRAP
VG312 g312 0 4.0000000000000000
X312 47 g312 11 b312 NMOSWRAP
VG313 g313 0 4.0000000000000000
X313 47 g313 12 b313 NMOSWRAP
VG314 g314 0 4.0000000000000000
X314 48 g314 3 b314 NMOSWRAP
VG315 g315 0 4.0000000000000000
X315 48 g315 4 b315 NMOSWRAP
VG316 g316 0 4.0000000000000000
X316 48 g316 5 b316 NMOSWRAP
VG317 g317 0 4.0000000000000000
X317 48 g317 6 b317 NMOSWRAP
VG318 g318 0 4.0000000000000000
X318 48 g318 7 b318 NMOSWRAP
VG319 g319 0 4.0000000000000000
X319 48 g319 8 b319 NMOSWRAP
VG320 g320 0 4.0000000000000000
X320 48 g320 9 b320 NMOSWRAP
VG321 g321 0 4.0000000000000000
X321 48 g321 10 b321 NMOSWRAP
VG322 g322 0 4.0000000000000000
X322 48 g322 11 b322 NMOSWRAP
VG323 g323 0 4.0000000000000000
X323 48 g323 12 b323 NMOSWRAP
VG324 g324 0 4.0000000000000000
X324 49 g324 4 b324 NMOSWRAP
VG325 g325 0 4.0000000000000000
X325 49 g325 5 b325 NMOSWRAP
VG326 g326 0 4.0000000000000000
X326 49 g326 6 b326 NMOSWRAP
VG327 g327 0 4.0000000000000000
X327 49 g327 7 b327 NMOSWRAP
VG328 g328 0 4.0000000000000000
X328 49 g328 8 b328 NMOSWRAP
VG329 g329 0 4.0000000000000000
X329 49 g329 9 b329 NMOSWRAP
VG330 g330 0 4.0000000000000000
X330 49 g330 10 b330 NMOSWRAP
VG331 g331 0 4.0000000000000000
X331 49 g331 11 b331 NMOSWRAP
VG332 g332 0 4.0000000000000000
X332 50 g332 3 b332 NMOSWRAP
VG333 g333 0 4.0000000000000000
X333 50 g333 4 b333 NMOSWRAP
VG334 g334 0 4.0000000000000000
X334 50 g334 6 b334 NMOSWRAP
VG335 g335 0 4.0000000000000000
X335 50 g335 7 b335 NMOSWRAP
VG336 g336 0 4.0000000000000000
X336 50 g336 8 b336 NMOSWRAP
VG337 g337 0 4.0000000000000000
X337 50 g337 9 b337 NMOSWRAP
VG338 g338 0 4.0000000000000000
X338 50 g338 10 b338 NMOSWRAP
VG339 g339 0 4.0000000000000000
X339 50 g339 11 b339 NMOSWRAP
VG340 g340 0 4.0000000000000000
X340 50 g340 12 b340 NMOSWRAP
VG341 g341 0 4.0000000000000000
X341 51 g341 3 b341 NMOSWRAP
VG342 g342 0 4.0000000000000000
X342 51 g342 4 b342 NMOSWRAP
VG343 g343 0 4.0000000000000000
X343 51 g343 5 b343 NMOSWRAP
VG344 g344 0 4.0000000000000000
X344 51 g344 6 b344 NMOSWRAP
VG345 g345 0 4.0000000000000000
X345 51 g345 7 b345 NMOSWRAP
VG346 g346 0 4.0000000000000000
X346 51 g346 8 b346 NMOSWRAP
VG347 g347 0 4.0000000000000000
X347 51 g347 9 b347 NMOSWRAP
VG348 g348 0 4.0000000000000000
X348 51 g348 10 b348 NMOSWRAP
VG349 g349 0 4.0000000000000000
X349 51 g349 12 b349 NMOSWRAP
VG350 g350 0 4.0000000000000000
X350 52 g350 3 b350 NMOSWRAP
VG351 g351 0 4.0000000000000000
X351 52 g351 4 b351 NMOSWRAP
VG352 g352 0 4.0000000000000000
X352 52 g352 5 b352 NMOSWRAP
VG353 g353 0 4.0000000000000000
X353 52 g353 6 b353 NMOSWRAP
VG354 g354 0 4.0000000000000000
X354 52 g354 7 b354 NMOSWRAP
VG355 g355 0 4.0000000000000000
X355 52 g355 8 b355 NMOSWRAP
VG356 g356 0 4.0000000000000000
X356 52 g356 9 b356 NMOSWRAP
VG357 g357 0 4.0000000000000000
X357 52 g357 10 b357 NMOSWRAP
VG358 g358 0 4.0000000000000000
X358 52 g358 11 b358 NMOSWRAP
VG359 g359 0 4.0000000000000000
X359 52 g359 12 b359 NMOSWRAP
VG360 g360 0 4.0000000000000000
X360 53 g360 3 b360 NMOSWRAP
VG361 g361 0 4.0000000000000000
X361 53 g361 4 b361 NMOSWRAP
VG362 g362 0 4.0000000000000000
X362 53 g362 6 b362 NMOSWRAP
VG363 g363 0 4.0000000000000000
X363 53 g363 7 b363 NMOSWRAP
VG364 g364 0 4.0000000000000000
X364 53 g364 8 b364 NMOSWRAP
VG365 g365 0 4.0000000000000000
X365 53 g365 9 b365 NMOSWRAP
VG366 g366 0 4.0000000000000000
X366 53 g366 10 b366 NMOSWRAP
VG367 g367 0 4.0000000000000000
X367 53 g367 11 b367 NMOSWRAP
VG368 g368 0 4.0000000000000000
X368 53 g368 12 b368 NMOSWRAP
VG369 g369 0 4.0000000000000000
X369 54 g369 3 b369 NMOSWRAP
VG370 g370 0 4.0000000000000000
X370 54 g370 4 b370 NMOSWRAP
VG371 g371 0 4.0000000000000000
X371 54 g371 5 b371 NMOSWRAP
VG372 g372 0 4.0000000000000000
X372 54 g372 6 b372 NMOSWRAP
VG373 g373 0 4.0000000000000000
X373 54 g373 7 b373 NMOSWRAP
VG374 g374 0 4.0000000000000000
X374 54 g374 9 b374 NMOSWRAP
VG375 g375 0 4.0000000000000000
X375 54 g375 10 b375 NMOSWRAP
VG376 g376 0 4.0000000000000000
X376 54 g376 11 b376 NMOSWRAP
VG377 g377 0 4.0000000000000000
X377 54 g377 12 b377 NMOSWRAP
VG378 g378 0 4.0000000000000000
X378 55 g378 3 b378 NMOSWRAP
VG379 g379 0 4.0000000000000000
X379 55 g379 4 b379 NMOSWRAP
VG380 g380 0 4.0000000000000000
X380 55 g380 5 b380 NMOSWRAP
VG381 g381 0 4.0000000000000000
X381 55 g381 7 b381 NMOSWRAP
VG382 g382 0 4.0000000000000000
X382 55 g382 9 b382 NMOSWRAP
VG383 g383 0 4.0000000000000000
X383 55 g383 10 b383 NMOSWRAP
VG384 g384 0 4.0000000000000000
X384 55 g384 11 b384 NMOSWRAP
VG385 g385 0 4.0000000000000000
X385 56 g385 3 b385 NMOSWRAP
VG386 g386 0 4.0000000000000000
X386 56 g386 4 b386 NMOSWRAP
VG387 g387 0 4.0000000000000000
X387 56 g387 5 b387 NMOSWRAP
VG388 g388 0 4.0000000000000000
X388 56 g388 7 b388 NMOSWRAP
VG389 g389 0 4.0000000000000000
X389 56 g389 8 b389 NMOSWRAP
VG390 g390 0 4.0000000000000000
X390 56 g390 9 b390 NMOSWRAP
VG391 g391 0 4.0000000000000000
X391 56 g391 10 b391 NMOSWRAP
VG392 g392 0 4.0000000000000000
X392 56 g392 11 b392 NMOSWRAP
VG393 g393 0 4.0000000000000000
X393 57 g393 3 b393 NMOSWRAP
VG394 g394 0 4.0000000000000000
X394 57 g394 4 b394 NMOSWRAP
VG395 g395 0 4.0000000000000000
X395 57 g395 6 b395 NMOSWRAP
VG396 g396 0 4.0000000000000000
X396 57 g396 7 b396 NMOSWRAP
VG397 g397 0 4.0000000000000000
X397 57 g397 8 b397 NMOSWRAP
VG398 g398 0 4.0000000000000000
X398 57 g398 9 b398 NMOSWRAP
VG399 g399 0 4.0000000000000000
X399 57 g399 10 b399 NMOSWRAP
VG400 g400 0 4.0000000000000000
X400 57 g400 11 b400 NMOSWRAP
VG401 g401 0 4.0000000000000000
X401 58 g401 3 b401 NMOSWRAP
VG402 g402 0 4.0000000000000000
X402 58 g402 4 b402 NMOSWRAP
VG403 g403 0 4.0000000000000000
X403 58 g403 6 b403 NMOSWRAP
VG404 g404 0 4.0000000000000000
X404 58 g404 7 b404 NMOSWRAP
VG405 g405 0 4.0000000000000000
X405 58 g405 8 b405 NMOSWRAP
VG406 g406 0 4.0000000000000000
X406 58 g406 9 b406 NMOSWRAP
VG407 g407 0 4.0000000000000000
X407 58 g407 10 b407 NMOSWRAP
VG408 g408 0 4.0000000000000000
X408 58 g408 11 b408 NMOSWRAP
VG409 g409 0 4.0000000000000000
X409 58 g409 12 b409 NMOSWRAP
VG410 g410 0 4.0000000000000000
X410 59 g410 3 b410 NMOSWRAP
VG411 g411 0 4.0000000000000000
X411 59 g411 6 b411 NMOSWRAP
VG412 g412 0 4.0000000000000000
X412 59 g412 7 b412 NMOSWRAP
VG413 g413 0 4.0000000000000000
X413 59 g413 8 b413 NMOSWRAP
VG414 g414 0 4.0000000000000000
X414 59 g414 9 b414 NMOSWRAP
VG415 g415 0 4.0000000000000000
X415 59 g415 10 b415 NMOSWRAP
VG416 g416 0 4.0000000000000000
X416 59 g416 11 b416 NMOSWRAP
VG417 g417 0 4.0000000000000000
X417 59 g417 12 b417 NMOSWRAP
VG418 g418 0 4.0000000000000000
X418 60 g418 3 b418 NMOSWRAP
VG419 g419 0 4.0000000000000000
X419 60 g419 4 b419 NMOSWRAP
VG420 g420 0 4.0000000000000000
X420 60 g420 5 b420 NMOSWRAP
VG421 g421 0 4.0000000000000000
X421 60 g421 6 b421 NMOSWRAP
VG422 g422 0 4.0000000000000000
X422 60 g422 7 b422 NMOSWRAP
VG423 g423 0 4.0000000000000000
X423 60 g423 8 b423 NMOSWRAP
VG424 g424 0 4.0000000000000000
X424 60 g424 9 b424 NMOSWRAP
VG425 g425 0 4.0000000000000000
X425 60 g425 10 b425 NMOSWRAP
VG426 g426 0 4.0000000000000000
X426 60 g426 12 b426 NMOSWRAP
VG427 g427 0 4.0000000000000000
X427 61 g427 3 b427 NMOSWRAP
VG428 g428 0 4.0000000000000000
X428 61 g428 4 b428 NMOSWRAP
VG429 g429 0 4.0000000000000000
X429 61 g429 5 b429 NMOSWRAP
VG430 g430 0 4.0000000000000000
X430 61 g430 6 b430 NMOSWRAP
VG431 g431 0 4.0000000000000000
X431 61 g431 7 b431 NMOSWRAP
VG432 g432 0 4.0000000000000000
X432 61 g432 8 b432 NMOSWRAP
VG433 g433 0 4.0000000000000000
X433 61 g433 9 b433 NMOSWRAP
VG434 g434 0 4.0000000000000000
X434 61 g434 11 b434 NMOSWRAP
VG435 g435 0 4.0000000000000000
X435 61 g435 12 b435 NMOSWRAP
VG436 g436 0 4.0000000000000000
X436 62 g436 3 b436 NMOSWRAP
VG437 g437 0 4.0000000000000000
X437 62 g437 4 b437 NMOSWRAP
VG438 g438 0 4.0000000000000000
X438 62 g438 5 b438 NMOSWRAP
VG439 g439 0 4.0000000000000000
X439 62 g439 6 b439 NMOSWRAP
VG440 g440 0 4.0000000000000000
X440 62 g440 7 b440 NMOSWRAP
VG441 g441 0 4.0000000000000000
X441 62 g441 8 b441 NMOSWRAP
VG442 g442 0 4.0000000000000000
X442 62 g442 9 b442 NMOSWRAP
VG443 g443 0 4.0000000000000000
X443 62 g443 10 b443 NMOSWRAP
VG444 g444 0 4.0000000000000000
X444 62 g444 11 b444 NMOSWRAP
VG445 g445 0 4.0000000000000000
X445 62 g445 12 b445 NMOSWRAP
VG446 g446 0 4.0000000000000000
X446 63 g446 3 b446 NMOSWRAP
VG447 g447 0 4.0000000000000000
X447 63 g447 4 b447 NMOSWRAP
VG448 g448 0 4.0000000000000000
X448 63 g448 5 b448 NMOSWRAP
VG449 g449 0 4.0000000000000000
X449 63 g449 6 b449 NMOSWRAP
VG450 g450 0 4.0000000000000000
X450 63 g450 7 b450 NMOSWRAP
VG451 g451 0 4.0000000000000000
X451 63 g451 8 b451 NMOSWRAP
VG452 g452 0 4.0000000000000000
X452 63 g452 9 b452 NMOSWRAP
VG453 g453 0 4.0000000000000000
X453 63 g453 10 b453 NMOSWRAP
VG454 g454 0 4.0000000000000000
X454 63 g454 11 b454 NMOSWRAP
VG455 g455 0 4.0000000000000000
X455 64 g455 3 b455 NMOSWRAP
VG456 g456 0 4.0000000000000000
X456 64 g456 4 b456 NMOSWRAP
VG457 g457 0 4.0000000000000000
X457 64 g457 5 b457 NMOSWRAP
VG458 g458 0 4.0000000000000000
X458 64 g458 6 b458 NMOSWRAP
VG459 g459 0 4.0000000000000000
X459 64 g459 7 b459 NMOSWRAP
VG460 g460 0 4.0000000000000000
X460 64 g460 8 b460 NMOSWRAP
VG461 g461 0 4.0000000000000000
X461 64 g461 9 b461 NMOSWRAP
VG462 g462 0 4.0000000000000000
X462 64 g462 10 b462 NMOSWRAP
VG463 g463 0 4.0000000000000000
X463 64 g463 12 b463 NMOSWRAP
VG464 g464 0 4.0000000000000000
X464 65 g464 3 b464 NMOSWRAP
VG465 g465 0 4.0000000000000000
X465 65 g465 4 b465 NMOSWRAP
VG466 g466 0 4.0000000000000000
X466 65 g466 5 b466 NMOSWRAP
VG467 g467 0 4.0000000000000000
X467 65 g467 6 b467 NMOSWRAP
VG468 g468 0 4.0000000000000000
X468 65 g468 7 b468 NMOSWRAP
VG469 g469 0 4.0000000000000000
X469 65 g469 8 b469 NMOSWRAP
VG470 g470 0 4.0000000000000000
X470 65 g470 9 b470 NMOSWRAP
VG471 g471 0 4.0000000000000000
X471 65 g471 11 b471 NMOSWRAP
VG472 g472 0 4.0000000000000000
X472 65 g472 12 b472 NMOSWRAP
VG473 g473 0 4.0000000000000000
X473 66 g473 3 b473 NMOSWRAP
VG474 g474 0 4.0000000000000000
X474 66 g474 4 b474 NMOSWRAP
VG475 g475 0 4.0000000000000000
X475 66 g475 5 b475 NMOSWRAP
VG476 g476 0 4.0000000000000000
X476 66 g476 6 b476 NMOSWRAP
VG477 g477 0 4.0000000000000000
X477 66 g477 7 b477 NMOSWRAP
VG478 g478 0 4.0000000000000000
X478 66 g478 8 b478 NMOSWRAP
VG479 g479 0 4.0000000000000000
X479 66 g479 9 b479 NMOSWRAP
VG480 g480 0 4.0000000000000000
X480 66 g480 11 b480 NMOSWRAP
VG481 g481 0 4.0000000000000000
X481 66 g481 12 b481 NMOSWRAP
VG482 g482 0 4.0000000000000000
X482 67 g482 3 b482 NMOSWRAP
VG483 g483 0 4.0000000000000000
X483 67 g483 4 b483 NMOSWRAP
VG484 g484 0 4.0000000000000000
X484 67 g484 5 b484 NMOSWRAP
VG485 g485 0 4.0000000000000000
X485 67 g485 6 b485 NMOSWRAP
VG486 g486 0 4.0000000000000000
X486 67 g486 9 b486 NMOSWRAP
VG487 g487 0 4.0000000000000000
X487 67 g487 10 b487 NMOSWRAP
VG488 g488 0 4.0000000000000000
X488 67 g488 11 b488 NMOSWRAP
VG489 g489 0 4.0000000000000000
X489 67 g489 12 b489 NMOSWRAP
VG490 g490 0 4.0000000000000000
X490 68 g490 3 b490 NMOSWRAP
VG491 g491 0 4.0000000000000000
X491 68 g491 4 b491 NMOSWRAP
VG492 g492 0 4.0000000000000000
X492 68 g492 5 b492 NMOSWRAP
VG493 g493 0 4.0000000000000000
X493 68 g493 6 b493 NMOSWRAP
VG494 g494 0 4.0000000000000000
X494 68 g494 8 b494 NMOSWRAP
VG495 g495 0 4.0000000000000000
X495 68 g495 9 b495 NMOSWRAP
VG496 g496 0 4.0000000000000000
X496 68 g496 10 b496 NMOSWRAP
VG497 g497 0 4.0000000000000000
X497 68 g497 11 b497 NMOSWRAP
VG498 g498 0 4.0000000000000000
X498 68 g498 12 b498 NMOSWRAP
VG499 g499 0 4.0000000000000000
X499 69 g499 3 b499 NMOSWRAP
VG500 g500 0 4.0000000000000000
X500 69 g500 4 b500 NMOSWRAP
VG501 g501 0 4.0000000000000000
X501 69 g501 5 b501 NMOSWRAP
VG502 g502 0 4.0000000000000000
X502 69 g502 6 b502 NMOSWRAP
VG503 g503 0 4.0000000000000000
X503 69 g503 7 b503 NMOSWRAP
VG504 g504 0 4.0000000000000000
X504 69 g504 8 b504 NMOSWRAP
VG505 g505 0 4.0000000000000000
X505 69 g505 9 b505 NMOSWRAP
VG506 g506 0 4.0000000000000000
X506 69 g506 10 b506 NMOSWRAP
VG507 g507 0 4.0000000000000000
X507 69 g507 11 b507 NMOSWRAP
VG508 g508 0 4.0000000000000000
X508 70 g508 3 b508 NMOSWRAP
VG509 g509 0 4.0000000000000000
X509 70 g509 4 b509 NMOSWRAP
VG510 g510 0 4.0000000000000000
X510 70 g510 5 b510 NMOSWRAP
VG511 g511 0 4.0000000000000000
X511 70 g511 6 b511 NMOSWRAP
VG512 g512 0 4.0000000000000000
X512 70 g512 7 b512 NMOSWRAP
VG513 g513 0 4.0000000000000000
X513 70 g513 8 b513 NMOSWRAP
VG514 g514 0 4.0000000000000000
X514 70 g514 9 b514 NMOSWRAP
VG515 g515 0 4.0000000000000000
X515 70 g515 10 b515 NMOSWRAP
VG516 g516 0 4.0000000000000000
X516 70 g516 11 b516 NMOSWRAP
VG517 g517 0 4.0000000000000000
X517 70 g517 12 b517 NMOSWRAP
VG518 g518 0 4.0000000000000000
X518 71 g518 3 b518 NMOSWRAP
VG519 g519 0 4.0000000000000000
X519 71 g519 5 b519 NMOSWRAP
VG520 g520 0 4.0000000000000000
X520 71 g520 6 b520 NMOSWRAP
VG521 g521 0 4.0000000000000000
X521 71 g521 7 b521 NMOSWRAP
VG522 g522 0 4.0000000000000000
X522 71 g522 8 b522 NMOSWRAP
VG523 g523 0 4.0000000000000000
X523 71 g523 9 b523 NMOSWRAP
VG524 g524 0 4.0000000000000000
X524 71 g524 10 b524 NMOSWRAP
VG525 g525 0 4.0000000000000000
X525 71 g525 12 b525 NMOSWRAP
VG526 g526 0 4.0000000000000000
X526 72 g526 3 b526 NMOSWRAP
VG527 g527 0 4.0000000000000000
X527 72 g527 4 b527 NMOSWRAP
VG528 g528 0 4.0000000000000000
X528 72 g528 5 b528 NMOSWRAP
VG529 g529 0 4.0000000000000000
X529 72 g529 6 b529 NMOSWRAP
VG530 g530 0 4.0000000000000000
X530 72 g530 8 b530 NMOSWRAP
VG531 g531 0 4.0000000000000000
X531 72 g531 10 b531 NMOSWRAP
VG532 g532 0 4.0000000000000000
X532 72 g532 11 b532 NMOSWRAP
VG533 g533 0 4.0000000000000000
X533 72 g533 12 b533 NMOSWRAP
VG534 g534 0 4.0000000000000000
X534 73 g534 3 b534 NMOSWRAP
VG535 g535 0 4.0000000000000000
X535 73 g535 4 b535 NMOSWRAP
VG536 g536 0 4.0000000000000000
X536 73 g536 5 b536 NMOSWRAP
VG537 g537 0 4.0000000000000000
X537 73 g537 6 b537 NMOSWRAP
VG538 g538 0 4.0000000000000000
X538 73 g538 7 b538 NMOSWRAP
VG539 g539 0 4.0000000000000000
X539 73 g539 8 b539 NMOSWRAP
VG540 g540 0 4.0000000000000000
X540 73 g540 9 b540 NMOSWRAP
VG541 g541 0 4.0000000000000000
X541 73 g541 11 b541 NMOSWRAP
VG542 g542 0 4.0000000000000000
X542 73 g542 12 b542 NMOSWRAP
VG543 g543 0 4.0000000000000000
X543 74 g543 3 b543 NMOSWRAP
VG544 g544 0 4.0000000000000000
X544 74 g544 4 b544 NMOSWRAP
VG545 g545 0 4.0000000000000000
X545 74 g545 5 b545 NMOSWRAP
VG546 g546 0 4.0000000000000000
X546 74 g546 6 b546 NMOSWRAP
VG547 g547 0 4.0000000000000000
X547 74 g547 8 b547 NMOSWRAP
VG548 g548 0 4.0000000000000000
X548 74 g548 9 b548 NMOSWRAP
VG549 g549 0 4.0000000000000000
X549 74 g549 11 b549 NMOSWRAP
VG550 g550 0 4.0000000000000000
X550 74 g550 12 b550 NMOSWRAP
VG551 g551 0 4.0000000000000000
X551 75 g551 3 b551 NMOSWRAP
VG552 g552 0 4.0000000000000000
X552 75 g552 4 b552 NMOSWRAP
VG553 g553 0 4.0000000000000000
X553 75 g553 5 b553 NMOSWRAP
VG554 g554 0 4.0000000000000000
X554 75 g554 6 b554 NMOSWRAP
VG555 g555 0 4.0000000000000000
X555 75 g555 7 b555 NMOSWRAP
VG556 g556 0 4.0000000000000000
X556 75 g556 8 b556 NMOSWRAP
VG557 g557 0 4.0000000000000000
X557 75 g557 9 b557 NMOSWRAP
VG558 g558 0 4.0000000000000000
X558 75 g558 10 b558 NMOSWRAP
VG559 g559 0 4.0000000000000000
X559 75 g559 11 b559 NMOSWRAP
VG560 g560 0 4.0000000000000000
X560 75 g560 12 b560 NMOSWRAP
VG561 g561 0 4.0000000000000000
X561 76 g561 3 b561 NMOSWRAP
VG562 g562 0 4.0000000000000000
X562 76 g562 4 b562 NMOSWRAP
VG563 g563 0 4.0000000000000000
X563 76 g563 5 b563 NMOSWRAP
VG564 g564 0 4.0000000000000000
X564 76 g564 6 b564 NMOSWRAP
VG565 g565 0 4.0000000000000000
X565 76 g565 7 b565 NMOSWRAP
VG566 g566 0 4.0000000000000000
X566 76 g566 8 b566 NMOSWRAP
VG567 g567 0 4.0000000000000000
X567 76 g567 9 b567 NMOSWRAP
VG568 g568 0 4.0000000000000000
X568 76 g568 10 b568 NMOSWRAP
VG569 g569 0 4.0000000000000000
X569 76 g569 11 b569 NMOSWRAP
VG570 g570 0 4.0000000000000000
X570 76 g570 12 b570 NMOSWRAP
.options TEMP = 27C
.options TNOM = 27C
.options itl1=40 itl2=40 itl4=6 itl5=60
.options gmin=1e-8 reltol=5e-3 abstol=1e-8 vntol=1e-5
.options rshunt=1e9
.op
.end
